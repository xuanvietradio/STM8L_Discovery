# IAR project 1_First_Project.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8L152C6 STM8L152C6
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8L15X_LD
  ICCSTM8.CCIncludePath2: ..\STM8L15x_StdPeriph_Driver\inc; C:\Users\Administrator\Documents\GitHub\STM8L_Discovery\user\1_First_Project
  ICCSTM8.IccLang: 0
  ILINK.IlinkOutputFile: First_Project.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group lib
    ../STM8L15x_StdPeriph_Driver/src/: stm8l15x_clk.c stm8l15x_gpio.c
  group user
    ../user/1_First_Project/: main.c stm8l15x_it.c
